** sch_path: verification/testbenches/inv/inv_tb.sch
**.subckt inv_tb
x1 net1 net2 inv
V1 net2 net3 3
C1 net1 GND 1p m=1
**.ends

* expanding   symbol:  /home/mateo/GitRepos/EAMTA2026-VLSI/design/blocks/test-wf/schematic/inv.sym #
*+ of pins=2
** sym_path: /home/mateo/GitRepos/EAMTA2026-VLSI/design/blocks/test-wf/schematic/inv.sym
** sch_path: /home/mateo/GitRepos/EAMTA2026-VLSI/design/blocks/test-wf/schematic/inv.sch
.subckt inv OUT[expr(@width - 1):0] IN[expr(@width - 1):0]
*.ipin IN[@width - 1:0]
*.opin OUT[@width - 1:0]
M1[@width - 1:0] OUT[@width - 1:0] IN[@width - 1:0] GND GND cmosn w=2u l=1u m=1
M2[@width -1:0] OUT[@width - 1:0] IN[@width - 1:0] VDD VDD cmosp w=5u l=1u m=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
